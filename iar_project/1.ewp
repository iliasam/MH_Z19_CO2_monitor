# IAR project 1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD_VL; HAVE_CONFIG_H
  ICCARM.CCIncludePath2: .\inc; ..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 1.bin
  ILINK.IlinkOutputFile: 1.out
  ILINK.IlinkIcfFile: D:\MYPROGS\STM32\CO2\PROG4\PROG4\stm32f100_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group src
    src/: character_table.h co2_sensor.c co2_sensor.h hardware_work.c hardware_work.h i2c_functions.c i2c_functions.h icons.h init_periph.c init_periph.h key_handler.c key_handler.h lm75.c lm75.h main.c main.h menu_handler.c menu_handler.h SSD1306.c SSD1306.h stm32f10x_it.c stm32f10x_it.h
  group src/CMSIS
    src/CMSIS/: system_stm32f10x.c
  group src/inc
    src/inc/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.h
  group src/startup
    src/startup/: startup_stm32f10x_md_vl.s
  group src/StdPeriphLib
    src/StdPeriphLib/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
